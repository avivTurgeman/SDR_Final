options:
  parameters:
    author: Aviv & Avichi
    generate_options: qt_gui
    id: car_key
    output_language: python
    title: Car Key 'Lock', 'Unlock' detecter
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    orient: QtCore.Qt.Vertical
    start: 1e6
    step: '100000'
    stop: 3e6
    value: 2.4e6
    widget: slider
  states: {}
- name: bit_rate
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '500'
    stop: '8000'
    value: '3000'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '433900000'
    step: '10000'
    stop: '434100000'
    value: '433920000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '40'
    value: '10'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: '100000'
    stop: 3e6
    value: 2.4e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: sync
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: '0.25'
    mu: '0.5'
    omega: samp_rate/bit_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '1010100011'
    tagname: sync
    threshold: '0'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      # Remote Button Decoder
      from gnuradio import gr
      import pmt

      COMMAND_MAP = {
          0x1: "Lock pressed",
          0x2: "Unlock pressed",
      }

      def bits_to_int(bits):
          val = 0
          for b in bits:
              val = (val<<1) | b
          return val

      class remote_button_decoder(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Button Decoder", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_pdu)
              self.message_port_register_out(pmt.intern("out"))

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data = pmt.cdr(pdu)
              try: bits = list(pmt.u8vector_elements(data))
              except: bits = list(pmt.to_python(data))
              if len(bits) < 20: return
              cmd = bits_to_int(bits[16:20])         # הנח שה־command ב-4 הביטים הללו
              text = COMMAND_MAP.get(cmd)
              if text:
                  self.message_port_pub(pmt.intern("out"), pmt.cons(meta, pmt.string_to_symbol(text)))
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bit_rate*2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: bit_rate
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: rf_gain
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    srate: samp_rate
    type: msg_complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0, out, qtgui_time_sink_x_0, in]
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
